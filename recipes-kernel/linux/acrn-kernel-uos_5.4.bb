require acrn-kernel_5.4.inc

SRC_URI:append = "  file://uos_5.4.scc"

LINUX_VERSION_EXTENSION = "-acrn-kernel-uos"

SUMMARY = "ACRN Kernel (UOS)"
