require acrn-hypervisor.bb
require acrn-common-dev.inc

PROVIDES = "acrn-hypervisor"
RPROVIDES_${PN} += "acrn-hypervisor"
