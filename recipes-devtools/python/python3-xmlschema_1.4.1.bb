require python-xmlschema.inc
inherit pypi setuptools3

SRC_URI[md5sum] = "f4c46f8c4415a0ca31dc2f623b668664"
SRC_URI[sha256sum] = "ade693114ff2e4a9ed5a2371ce29ae888f689bc58e326e5796f8a7dc8954dd4a"
