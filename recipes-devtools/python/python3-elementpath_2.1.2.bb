require python-elementpath.inc
inherit pypi setuptools3

SRC_URI[md5sum] = "887f60e9c4fb9b0804a38372b2798101"
SRC_URI[sha256sum] = "23e1fed8d196d9a6cc4d220ef11fbe7eb8cff3a27848621c447e9d96134b2085"
