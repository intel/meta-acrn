require linux-intel-ese-acrn.inc

SRC_URI_append = "  file://uos_5.4.scc"

LINUX_VERSION_EXTENSION = "-linux-intel-ese-lts-acrn-uos"

SUMMARY = "Linux Intel ESE Kernel with ACRN enabled (UOS)"
